# IAR project AS32_project.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: AS32x601_InternalFlash ANSILIC AS32x601_InternalFlash
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: DEBUG
  ICCRISCV.CCIncludePath2: User; Bsp; ..\..\Core; ..\..\Peripherals\inc; ..\..\Peripherals\reg; ..\..\Startup; ..\..\System
  OBJCOPY.OOCOutputFile: AS32_project.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: AS32_project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ANSILIC\AS32x601_InternalFlash.icf
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCDefines: NDEBUG
  group Bsp
    Bsp/: adc.c canfd.c canfd_xieyi.c gpio.c iic.c onewire.c print.c uart_dianji.c uart_xingjian.c
  group Core
    ../../Core/: as32x601_trapentry.S
  group Peripherals
    ../../Peripherals/src/: as32x601_adc.c as32x601_canfd.c as32x601_clint.c as32x601_cmu.c as32x601_core.c as32x601_crc.c as32x601_dac.c as32x601_dma.c as32x601_flash.c as32x601_gpio.c as32x601_i2c.c as32x601_iwdg.c as32x601_mac.c as32x601_mpu.c as32x601_plic.c as32x601_pmu.c as32x601_qspi.c as32x601_rtc.c as32x601_smu.c as32x601_spi.c as32x601_timer.c as32x601_usart.c as32x601_wwdg.c
  group Startup
    ../../Startup/: as32x601_startup.S
  group System
    ../../System/: delay.c myprintf.c
  group User
    User/: main.c
